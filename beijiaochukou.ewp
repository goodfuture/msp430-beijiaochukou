# IAR project beijiaochukou.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430FG4618 MSP430FG4618
  General.GStackSize2: 120
  General.GHeapSize2: 80
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: lnk430FG4618app.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: AT24C64.c cpu.h cpu_init.c cstartup.s43 define.h flash.c IS752_driver.c LCD.c main.c modbus.c msp430xG46x.h protocol.c runlog.c test.h times.c update.c update.h updateS.s43 zimo.h
